# Keil uVision project STM32_LwESP.uvprojx, settings and files
target STM32_LwESP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST;..\Core;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User\inc;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM3;..\Middlewares\FreeRTOS;..\Middlewares\lwesp\src\include;..\Middlewares\lwesp;..\Middlewares\lwesp\src\include\system\port\freertos;..\Middlewares\lwesp\snippets\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Core
    ../Core/: stm32f10x_it.c system_stm32f10x.c core_cm3.c startup_stm32f10x_hd.s
  group User
    ../User/src/: main.c printf.c delay.c
    ../Middlewares/FreeRTOS/: FreeRTOSConfig.h
    ../Middlewares/lwesp/: lwesp_opts.h
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Middlewares/FreeRTOS_CORE
    ../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS_PORT
    ../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ../Middlewares/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group Middlewares/LwESP/api
    ../Middlewares/lwesp/src/api/: lwesp_netconn.c
  group Middlewares/LwESP/cli
    ../Middlewares/lwesp/src/cli/: cli.c cli_input.c
  group Middlewares/LwESP/lwesp
    ../Middlewares/lwesp/src/lwesp/: lwesp.c lwesp_ap.c lwesp_buff.c lwesp_cli.c lwesp_conn.c lwesp_debug.c lwesp_dhcp.c lwesp_dns.c lwesp_evt.c lwesp_hostname.c lwesp_input.c lwesp_int.c lwesp_mdns.c lwesp_mem.c lwesp_parser.c lwesp_pbuf.c lwesp_ping.c lwesp_server.c lwesp_smart.c lwesp_sntp.c lwesp_sta.c lwesp_threads.c lwesp_timeout.c lwesp_unicode.c lwesp_utils.c lwesp_webserver.c lwesp_wps.c
  group Middlewares/LwESP/system
    ../Middlewares/lwesp/src/system/: lwesp_ll_stm32.c lwesp_sys_freertos.c
  group Middlewares/LwESP/snippets
    ../Middlewares/lwesp/snippets/: station_manager.c utils.c netconn_client.c
